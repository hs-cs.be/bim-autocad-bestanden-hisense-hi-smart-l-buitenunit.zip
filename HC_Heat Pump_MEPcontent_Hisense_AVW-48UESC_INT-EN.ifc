Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-02-06T09:26:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 06 09:26:45 2018 * Host: B3ROBRAWR3858 * Database: C:\Users\DD\AppData\Local\Temp\{731881A2-1FB4-4E95-8284-FFC4731D6AD9}\ifc * Database version: 5507 * Database creation date: Tue Feb 06 09:26:43 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Feb 06 09:26:43 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 06 09:26:43 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcPump: AVW-48UESC, HC_Heat Pump_MEPcontent_Hisense_AVW38UCSC-54UESC_INT-EN:AVW-48UESC:1304213
In: V00
Type - Material: Color RGB 216-216-216, Color RGB 024-077-198, Color RGB 000-204-204
Type - Dimensions - Depth: 370 mm; Drain Diameter: 32 mm; Height: 1380 mm; Refrigerant Gas Diameter: 15.9 mm; Refrigerant Liquid Diameter: 9.53 mm; Width: 950 mm
Type - Electrical - ELB Nominal Current: 25 A; Hertz: 50 Hz; Maximum Running Current: 16.2 A; Phase: 3; Voltage: 400 V
Type - Identity Data - Article Description: Heat pump outdoor unit; Article Type: AVW-48UESC; Content Supplier URL: www.mepcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Heat pump outdoor unit; EMCS Version: 3.0; ETIM Article Class: EC001213; Family Version: 11.12; Manufacturer: Hisense; Manufacturer Art. No.: AVW-48UESC; Manufacturer URL: http://www.hs-cs.nl/; MEPcontent Class: HEATPUMP; Model: AVW-48UESC; OmniClass Number: 23.75.10.21; OmniClass Title: Heat Pumps; Product Line: Hi-Smart L series; Revit Version: 2016; Type Name: AVW-48UESC; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Blue: Color RGB 024-077-198; Grey: Color RGB 080-080-080; Logo: Color RGB 000-204-204; White: Color RGB 216-216-216
Type - Mechanical - Loads - Airflow Rate (m3/min): 90; Compressor Motor Output (kW): 2.5; Cooling Capacity (kW): 14; Cooling EER (kW/kW): 3.57; Cooling Power Input (kW): 3.92; Cooling Sound Pressure Level (dB(A)): 48; External Static Pressure (Pa): 0; Fan Motor Output (kW): 0.102; Heating Capacity (kW): 16; Heating COP (kW/kW): 3.97; Heating Power Input (kW): 4.03; Heating Sound Pressure Level (dB(A)): 50; Unit Weight (kg): 103
Type - Other - Category: Mechanical Equipment; Compressor Quantity: 1; Compressor Type: Hermetic DC inverter-driven scroll compressor; Family Name: HC_Heat Pump_MEPcontent_Hisense_AVW38UCSC-54UESC_INT-EN; Fan Quantity: 2; Fan Type: Axial-flow Fan; Indoor Unit Total Capacity: 50 to 130% of outdoor unit capacity; Refrigerant Charge (kg): 3.6; Refrigerant Type: R410A
Pset_ManufacturerTypeInformation - Manufacturer: Hisense
Constraints - Offset: 0 mm
Dimensions - Area: 7.79148 m2; Volume: 2.47583 m3
Electrical - Loads - Power: 0 W
Identity Data - Mark: 4
Mechanical - Drain Fixture Units: 0; Refrigerant Gas Flow: 0 m3/s; Refrigerant Liquid Flow: 0 m3/s; System Classification: Sanitary,Power,Undefined
Other - Back Clearance Safe: 300 mm; Family: HC_Heat Pump_MEPcontent_Hisense_AVW38UCSC-54UESC_INT-EN: AVW-48UESC; Family and Type: HC_Heat Pump_MEPcontent_Hisense_AVW38UCSC-54UESC_INT-EN: AVW-48UESC; Front Clearance Safe: 600 mm; Gas Connector Angle: 0 deg; Gas Connector Length: 80.5 mm; Left Clearance Safe: 50 mm; Liquid Connector Angle: 0 deg; Liquid Connector Length: 30.5 mm; Right Clearance Safe: 100 mm; Type: HC_Heat Pump_MEPcontent_Hisense_AVW38UCSC-54UESC_INT-EN: AVW-48UESC; Type Id: HC_Heat Pump_MEPcontent_Hisense_AVW38UCSC-54UESC_INT-EN: AVW-48UESC
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Back Clearance: 300 mm; Front Clearance: 600 mm; Front Connection: no; Left Clearance: 50 mm; Rear Connection: no; Right Clearance: 100 mm; Right Connection: no; Service Space: no
